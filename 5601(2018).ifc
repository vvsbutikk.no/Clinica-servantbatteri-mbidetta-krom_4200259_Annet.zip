Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-05-13T16:20:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon May 13 16:20:24 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{B6E1FE89-7D31-4A2E-B6B5-02416BA5C704}\ifc * Database version: 5507 * Database creation date: Mon May 13 16:20:23 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon May 13 16:20:23 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon May 13 16:20:23 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5601 Washbasin faucet, 5601(2018):5601 Washbasin faucet:346194
In: Level 1
Type - PredefinedType: FAUCET; Material: Copper
Type - Dimensions(Type) - FaucetNominalDepth: 166.629 mm; FaucetNominalHeight: 171 mm; FaucetNominalWidth: 50 mm; HandShowerNominalDepth: 64 mm; HandShowerNominalHeight: 338.2 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 5601(2018); ConvergoRefNr: 0087-1905-0003-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basin and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 09/04/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HC; Customs Code: 84818011; EAN Number: 6414150087691; EN Standard: EN 817; LVI Number: 6110267; Noise Class: I (ISO 3822); NRF Number: 4200259
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/5601; Catalog Drawing URL: http://static.oras.com/catdrw/5601; Class: Single lever, bidetta; Dimension Drawing URL: http://static.oras.com/dimdrw/5601; FDV Document URL: http://www.oras.com/datasheet/5601/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5601; Group: Washbasin faucets; Long Marketing: Oras Clinica washbasin faucet with disinfection proof Bidetta hand shower set. Firm loop-lever offers good usability to all users and situations. Fixed spout with nickel-free water channels and laminar water flow. In-built limitation options for water temperature and maximum flow-rate. Connection pipes Cu ø10 mm.; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 5601 Washbasin faucet; Name_en: 5601 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 585 x 225 x 95; Package Weight: 2.438 kg; Product Code: 5601; Product Datasheet: https://www.oras.com/datasheet/5601/en; Product Family: Oras Clinica; Product Image URL: http://static.oras.com/image/5601; Product URL: http://static.oras.com/5601; Type Name: 5601 Washbasin faucet; Usage Group: Toilets for the Disabled;Pharmacies, Opticians, Dentists;Health centers & Child welfare clinics;Hospitals
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Waterways without nickel coating;3S-Installation; Aerator: Laminar; Diverter: Integrated diverter / automatic reset; DN Size: DN15; Flow: Limitation option for maximum flow-rate; Flow Rate At 300kPa: 0.00741608 m3/s; Hand Shower: Bidetta hand shower; Installation and Maintenance: http://static.oras.com/manual/5601; Installation Type: Deck mounted; Lever Handle: Loop lever;Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Number of Shower Sprays: 1 spray; Pipes: Copper inlet pipe(s); Pressure Loss With Flow 01ls: 70000 Pa; Shower Parts: Shower Hose (1500 mm);Shower holder; Shower Spray: Sensitive; Spare Parts: http://static.oras.com/sp/5601; Spout Type: Fixed spout; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Health care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5601(2018); Features: Single lever, bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5601; Name: 5601 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x167x171 mm / Hand shower: 46x64x338 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Health Sales Arguments: Surfaces in contact with drinking water do not have a nickel coating.
Pset_ManufacturerTypeInformation - ModelReference: 5601; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 5601 Washbasin faucet
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; HandshowerVisibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0866582 m2; Volume: 0.00242823 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 5601(2018): 5601 Washbasin faucet; Family and Type: 5601(2018): 5601 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5601(2018): 5601 Washbasin faucet; Type Id: 5601(2018): 5601 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
